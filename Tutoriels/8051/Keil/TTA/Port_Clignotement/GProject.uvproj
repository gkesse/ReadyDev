# Keil uVision project GProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GProject +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SCH_MAX_TASKS=1
  c include: ..\..\..\Simple;..\..\..\TTA
  group Source Group 1
    ./: main.c
    ../../../TTA/: GPortFlash.c GSch.c
