# Keil uVision project GProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GProject +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\Objet;..\..\..\Strategie
  group Source Group 1
    ./: main.c
    ../../../Strategie/: GLedFlash.c GPortFlash.c GProcess.c
    ../../../Objet/: GDelay.c
